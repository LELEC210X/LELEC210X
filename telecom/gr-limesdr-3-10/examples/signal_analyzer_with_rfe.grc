<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>Lime Microsystems</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Signal analyzer</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>analog_filter_bandwidth_rx</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>RX analog filter bandwidth [MHz]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>baseband_rx</value></param>
<param><key>value</key><value>600</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>RX baseband [MHz]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>digital_filter_bandwidth_rx</value></param>
<param><key>value</key><value>sample_rate/2e6</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
<param><key>label</key><value>RX digital filter bandwidth [MHz]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_rx</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>RX gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>70</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>nco_freq_rx</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>label</key><value>RX NCO [MHz]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>rfe_attenuation</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>label</key><value>RFE Attenuation [dB]</value></param>
<param><key>labels</key><value>['0', '2', '4', '6', '8', '10', '12', '14']</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0, 1, 2, 3, 4, 5 ,6 , 7]</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>rfe_mode</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>label0</key><value>RX</value></param>
<param><key>label1</key><value>NONE</value></param>
<param><key>label2</key><value>TXRX</value></param>
<param><key>label</key><value>LimeRFE Mode</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>2</value></param>
<param><key>option2</key><value>3</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>rfe_notch</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>4,0,1,1</value></param>
<param><key>label0</key><value>Enabled</value></param>
<param><key>label1</key><value>Disabled</value></param>
<param><key>label</key><value>AM/FM Notch Filter</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>1</value></param>
<param><key>option1</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>5e6</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Sample rate [S/s]</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>limesdr_fpga_rfe</key>
<param><key>id</key><value>limesdr_fpga_rfe_0</value></param>
<param><key>notch</key><value>rfe_notch</value></param>
<param><key>comm_type</key><value>1</value></param>
<param><key>filename</key><value></value></param>
<param><key>fan</key><value>0</value></param>
<param><key>mode</key><value>rfe_mode</value></param>
<param><key>atten</key><value>rfe_attenuation</value></param>
<param><key>rx_channel</key><value>-2</value></param>
<param><key>rx_port</key><value>1</value></param>
<param><key>sdr_serial</key><value></value></param>
<param><key>tx_channel</key><value>-2</value></param>
<param><key>tx_port</key><value>2</value></param>
<param><key>com_port</key><value></value></param>
</block>
<block>
<key>limesdr_fpga_source</key>
<param><key>id</key><value>limesdr_fpga_source_0</value></param>
<param><key>allow_tcxo_dac</key><value>0</value></param>
<param><key>analog_bandw_ch0</key><value>analog_filter_bandwidth_rx*1e6</value></param>
<param><key>analog_bandw_ch1</key><value>0</value></param>
<param><key>calibr_bandw_ch0</key><value>sample_rate</value></param>
<param><key>calibr_bandw_ch1</key><value>0</value></param>
<param><key>channel_mode</key><value>0</value></param>
<param><key>serial</key><value></value></param>
<param><key>digital_bandw_ch0</key><value>digital_filter_bandwidth_rx*1e6</value></param>
<param><key>digital_bandw_ch1</key><value>0</value></param>
<param><key>filename</key><value></value></param>
<param><key>gain_dB_ch0</key><value>gain_rx</value></param>
<param><key>gain_dB_ch1</key><value>0</value></param>
<param><key>lna_path_ch0</key><value>255</value></param>
<param><key>lna_path_ch1</key><value>2</value></param>
<param><key>nco_freq_ch0</key><value>nco_freq_rx*1e6</value></param>
<param><key>nco_freq_ch1</key><value>0</value></param>
<param><key>oversample</key><value>0</value></param>
<param><key>rf_freq</key><value>baseband_rx*1e6</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>dacVal</key><value>125</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>sample_rate</value></param>
<param><key>fc</key><value>baseband_rx*1e6</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>5,0,1,2</value></param>
<param><key>name</key><value></value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>limesdr_fpga_source_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
