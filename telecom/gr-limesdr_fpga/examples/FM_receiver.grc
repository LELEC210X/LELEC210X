options:
  parameters:
    author: Lime Microsystems
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: FM Receiver
  states: {}

blocks:
- name: baseband
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: RX Baseband [MHz]
    type: real
    value: '100'
  states: {}
- name: cut_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Cutoff frequency
    orient: Qt.Horizontal
    start: 1e3
    step: 1e3
    stop: samp_rate/2
    value: 500e3
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Gain [dB]
    min_len: '70'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: lna_path
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    label: LNA Path
    label0: Auto
    label1: H
    label2: L
    label3: W
    num_opts: '4'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '255'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: trans_width
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Transition width
    orient: Qt.Horizontal
    start: 10e3
    step: '500'
    stop: 500e3
    value: 100e3
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '5'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: limesdr_fpga_source_0
  id: limesdr_fpga_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 2e6
    analog_bandw_ch1: 1.5e6
    calibr_bandw_ch0: 2.5e6
    calibr_bandw_ch1: 2.5e6
    channel_mode: '0'
    dacVal: '180'
    digital_bandw_ch0: 1.8e6
    digital_bandw_ch1: samp_rate
    filename: ''
    gain_dB_ch0: gain
    gain_dB_ch1: '1'
    lna_path_ch0: '255'
    lna_path_ch1: '2'
    nco_freq_ch0: '0'
    nco_freq_ch1: '0'
    oversample: '0'
    rf_freq: baseband*1e6
    samp_rate: samp_rate
    serial: ''
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_freq
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: trans_width
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: baseband*1e6
    fftsize: '1024'
    gui_hint: 3,0,15,2
    name: '"Low Pass filtered"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '200'
    interp: '48'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [limesdr_fpga_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
