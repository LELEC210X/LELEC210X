options:
  parameters:
    author: UCLouvain
    generate_options: qt_gui
    id: estimate_noise
    output_language: python
    title: LELEC2102 - Noise estimation
  states: {}

blocks:
- name: carrier_freq
  id: variable
  parameters:
    value: 868e6
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: fdev
  id: variable
  parameters:
    value: data_rate/2
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '73'
    value: '70'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 400e3
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: cc
  states: {state: disabled}
- name: fsk_noise_estimation_0
  id: fsk_noise_estimation
  parameters:
    n_samples: '4096'
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: ''
    analog_bandw_ch1: ''
    calibr_bandw_ch0: ''
    calibr_bandw_ch1: ''
    ch_align: 'False'
    channel_mode: '0'
    digital_bandw_ch0: ''
    digital_bandw_ch1: ''
    gain_dB_ch0: rx_gain
    gain_dB_ch1: ''
    lna_path_ch1: '1'
    oversample: '0'
    rf_freq: carrier_freq
    samp_rate: samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: data_rate+fdev
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: data_rate*1
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    rate: '33'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [dc_blocker_xx_0, '0', low_pass_filter_0, '0']
- [dc_blocker_xx_0, '0', qtgui_sink_x_0, '0']
- [limesdr_source_0, '0', dc_blocker_xx_0, '0']
- [limesdr_source_0, '0', low_pass_filter_0, '0']
- [limesdr_source_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', fsk_noise_estimation_0, '0']

metadata:
  file_format: 1
