options:
  parameters:
    author: UCLouvain
    generate_options: qt_gui
    id: eval_limesdr_fpga
    output_language: python
    title: LELEC2102 - Decode SDR with FPGA
  states: {}

blocks:
- name: Enable_chain
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: K_threshold
  id: variable_qtgui_range
  parameters:
    label: K factor for threshold
    rangeType: int
    start: '1'
    step: '1'
    stop: '254'
    value: '7'
  states: {}
- name: K_threshold
  id: variable
  parameters:
    value: '7'
  states: {state: disabled}
- name: carrier_freq
  id: variable
  parameters:
    value: 868e6
  states: {}
- name: crc_len
  id: variable
  parameters:
    value: '1'
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: detect_threshold
  id: variable
  parameters:
    value: '0.001'
  states: {}
- name: detect_threshold_entry
  id: variable_qtgui_entry
  parameters:
    label: Detection Threshold
    type: real
    value: '1e-3'
  states: {}
- name: estimated_noise_power
  id: variable
  parameters:
    value: '1e-06'
  states: {}
- name: fdev
  id: variable
  parameters:
    value: data_rate/4
  states: {}
- name: hdr_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: noiseQuery
  id: variable_qtgui_push_button
  parameters:
    label: Noise estimation query
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: hdr_len+payload_len+crc_len
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '100'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '70'
    value: '16'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '15'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: data_rate*8
  states: {}
- name: tx_power
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '-30'
    step: '1'
    stop: '30'
    value: '10'
  states: {}
- name: fsk_demodulation_0
  id: fsk_demodulation
  parameters:
    crc_len: crc_len
    drate: data_rate
    fdev: fdev
    fsamp: samp_rate
    payload_len: payload_len
  states: {}
- name: fsk_flag_detector_0
  id: fsk_flag_detector
  parameters:
    drate: data_rate
    enable: '1'
    fsamp: samp_rate
    packet_len: packet_len
  states: {state: disabled}
- name: fsk_onQuery_noise_estimation_0
  id: fsk_onQuery_noise_estimation
  parameters:
    n_est: '10'
    n_samples: '1024'
    query: noiseQuery
  states: {}
- name: fsk_packet_parser_0
  id: fsk_packet_parser
  parameters:
    address: '[0,0,1,1,1,1,1,0,0,0,1,0,1,0,1,0,0,1,0,1,0,1,0,0,1,0,1,1,0,1,1,1]'
    crc_len: crc_len
    hdr_len: hdr_len
    payload_len: payload_len
  states: {}
- name: fsk_preamble_detect_0
  id: fsk_preamble_detect
  parameters:
    drate: data_rate
    enable: Enable_chain
    fdev: fdev
    fsamp: samp_rate
    packet_len: packet_len
    threshold: detect_threshold_entry
  states: {}
- name: fsk_synchronization_0
  id: fsk_synchronization
  parameters:
    drate: data_rate
    fdev: fdev
    fsamp: samp_rate
    hdr_len: hdr_len
    packet_len: packet_len
    tx_power: tx_power
  states: {}
- name: limesdr_fpga_source_0
  id: limesdr_fpga_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 1.5e6
    analog_bandw_ch1: 1.5e6
    calibr_bandw_ch0: 2.5e6
    calibr_bandw_ch1: 2.5e6
    ch_align: 'False'
    channel_mode: '0'
    dacVal: '180'
    digital_bandw_ch0: samp_rate
    digital_bandw_ch1: samp_rate
    dspcfg_PASSTHROUGH_LEN: '(packet_len+1)*8*int(samp_rate/data_rate)+int(samp_rate/data_rate) '
    dspcfg_THRESHOLD: K_threshold
    dspcfg_preamble_en: '1'
    filename: ''
    gain_dB_ch0: rx_gain
    gain_dB_ch1: '1'
    lna_path_ch0: '255'
    lna_path_ch1: '2'
    nco_freq_ch0: '0'
    nco_freq_ch1: '0'
    oversample: '0'
    rf_freq: carrier_freq
    samp_rate: samp_rate
    serial: ''
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: SDR signal
    type: complex
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:10000
    timeout: '100'
    type: byte
    vlen: payload_len
  states: {}

connections:
- [fsk_demodulation_0, '0', fsk_packet_parser_0, '0']
- [fsk_flag_detector_0, '0', fsk_synchronization_0, '0']
- [fsk_onQuery_noise_estimation_0, NoisePow, fsk_synchronization_0, NoisePow]
- [fsk_packet_parser_0, '0', zeromq_pub_sink_0, '0']
- [fsk_preamble_detect_0, '0', fsk_synchronization_0, '0']
- [fsk_synchronization_0, '0', fsk_demodulation_0, '0']
- [limesdr_fpga_source_0, '0', fsk_flag_detector_0, '0']
- [limesdr_fpga_source_0, '0', fsk_onQuery_noise_estimation_0, '0']
- [limesdr_fpga_source_0, '0', fsk_preamble_detect_0, '0']
- [limesdr_fpga_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
