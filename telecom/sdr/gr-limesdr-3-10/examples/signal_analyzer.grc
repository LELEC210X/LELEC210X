options:
  parameters:
    author: Lime Microsystems
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Signal analyzer
  states: {}

blocks:
- name: analog_filter
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0,1,1
    label: Analog filter bandwidth [MHz]
    type: real
    value: samp_rate/1e6
  states: {}
- name: baseband
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: RX Baseband [MHz]
    type: real
    value: '100'
  states: {}
- name: digital_filter
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,1,1,1
    label: Digital filter bandwidth [MHz]
    type: real
    value: samp_rate/1e6 - 0.3
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Gain [dB]
    min_len: '70'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: lna_path
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,1,1,1
    label: LNA Path
    label0: Auto
    label1: H
    label2: L
    label3: W
    num_opts: '4'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '255'
  states: {}
- name: nco
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: NCO [MHz]
    type: real
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: limesdr_fpga_source_0
  id: limesdr_fpga_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: analog_filter*1e6
    analog_bandw_ch1: 1.5e6
    calibr_bandw_ch0: samp_rate
    calibr_bandw_ch1: 2.5e6
    channel_mode: '0'
    dacVal: '180'
    digital_bandw_ch0: digital_filter*1e6
    digital_bandw_ch1: samp_rate
    filename: ''
    gain_dB_ch0: gain
    gain_dB_ch1: '1'
    lna_path_ch0: lna_path
    lna_path_ch1: '2'
    nco_freq_ch0: nco
    nco_freq_ch1: '0'
    oversample: '0'
    rf_freq: baseband*1e6
    samp_rate: samp_rate
    serial: ''
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: baseband*1e6
    fftsize: '4096'
    gui_hint: 3,0,2,2
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [limesdr_fpga_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
